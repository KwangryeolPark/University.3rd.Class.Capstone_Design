# IAR project Project01.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: H:\대학\3학년\2학기\캡스톤디자인2\Project01\res; H:\대학\3학년\2학기\캡스톤디자인2\Project01\res\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar; H:\대학\3학년\2학기\캡스톤디자인2\Project01\res\cortex_m3; H:\대학\3학년\2학기\캡스톤디자인2\Project01\res\stm32
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: Project01.hex
  ILINK.IlinkOutputFile: Project01.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group CMSIS
    res/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd_vl.s
  group lib
    res/stm32/: adc.h afio.h exti.h gpio.h rcc.h tim.h usart.h
    res/: inc.h typedef.h
    res/cortex_m3/: nvic.h
  group Project01
    ./: main.c
