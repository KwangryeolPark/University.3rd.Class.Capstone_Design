# IAR project arm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: res\coretex m3; res\stm32; kernel\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar; lib\printf; lib\ir_transmit\psy; lib\ir_transmit
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: arm.srec
  ILINK.IlinkOutputFile: arm.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group CMSIS
    kernel/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd_vl.s
  group lib/coretex m3
    res/coretex m3/: nvic.h
  group lib/ir_transmit
    lib/ir_transmit/: ir_structs.c ir_structs.h
  group lib/ir_transmit/psy
    lib/ir_transmit/psy/: ir_receive_psy.c ir_receive_psy.h ir_transmit_psy.c ir_transmit_psy.h
  group lib/printf
    lib/printf/: printf.c printf.h
  group lib/stm32
    res/stm32/: adc.c adc.h afio.c afio.h delay.c delay.h exti.c exti.h gpio.c gpio.h rcc.c rcc.h tim.c tim.h typedef.h usart.c usart.h
  group main
    ./: main.cpp
